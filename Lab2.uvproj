# Keil uVision project Lab2.uvproj, settings and files
target Target 1 (MCS-51)
  device: C501 Infineon
  cpu: IRAM(0-0xFF)  CLOCK(40000000)
  output: Lab2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Lab2.A51
